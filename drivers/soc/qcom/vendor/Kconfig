## drivers/soc/qcom/vendor/Kconfig
```kconfig
source "drivers/soc/qcom/vendor/vlog/Kconfig"
source "drivers/soc/qcom/vendor/logcat/Kconfig"
```
